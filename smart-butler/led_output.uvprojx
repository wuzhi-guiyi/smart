# Keil uVision project led_output.uvprojx, settings and files
target led_output Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKW41Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: led_output.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKW41Z512VHT4, FRDM_KW41Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: CMSIS;board;doc;drivers;source;startup;utilities;.\board
  asm define: DEBUG
  asm include: CMSIS;board;doc;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKW41Z512xxx4_flash.scf
  link misc: --remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h MKW41Z4.h MKW41Z4_features.h system_MKW41Z4.c system_MKW41Z4.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h
  group source
    source/: gpio_led_output.c
  group startup
    startup/: startup_MKW41Z4.s
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h
target led_output Release (ARM-ADS)
  device: MKW41Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: led_output.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKW41Z512VHT4, FRDM_KW41Z, FREEDOM
  c misc: as above
  c include: CMSIS;board;doc;drivers;source;startup;utilities
  asm include: CMSIS;board;doc;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKW41Z512xxx4_flash.scf
  link misc: --remove
